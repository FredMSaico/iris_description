Commit message: Update launch and rviz files, add licences

File: urdf/iris.urdf (robot description, URDF)
Before this commit: robot iris_drone, 6 links, 5 joints
Links:
- link rplidar_link: geometry collision cylinder length=0.005 radius=0.08; visual box size=0.02 0.05 0.05
